Commit message: Add files via upload

File: xarm6_robotiq.urdf (robot description, URDF)
Before this commit: robot xarm6, 21 links, 20 joints
Joints:
- joint eef_joint: origin xyz=0 0 0.172 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 0
